require nextoomio-image.bb

SUMMARY = "nextoomio development image variant"
DESCRIPTION = "Development variant based on nextoomio-image. SSH server access is governed by nextoomio-ssh-keys via the selector partition key file per AD-23 and ARCHITECTURE.md section 3.7."
