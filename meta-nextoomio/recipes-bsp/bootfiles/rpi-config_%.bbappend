# Include nextoomio hardware boot configuration derived from the active hardware profile (ARCHITECTURE.md section 3.8, D-011)

RPI_EXTRA_CONFIG:append = "\n# nextoomio sound card hardware overlay include (ARCHITECTURE.md section 3.8, D-011)\ninclude nextoomio-hardware.txt\n"
